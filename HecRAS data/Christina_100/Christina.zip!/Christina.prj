HEC-RAS study Christina.prj: Christina River

--- Christina.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,7943    ,357.11,369.83,352.63
BEGIN DESCRIPTION:
Based on the old FIRM it appears the main channel as defined by the stream centerline is on the left side of the overbank. The old FIRM also shows the Floodway on the left side. Will assume this is correct.
END DESCRIPTION:
XS GIS Cut Line= 2
1648368.28791226745327.331544802 1647536.0286794745276.672287166
#Sta/Elev= 30
       0  239.85  100.93  237.28  152.26  238.06  180.24  239.41  208.23  239.91
  236.21  238.79   257.2  236.95  285.18  233.35  309.51  228.09  341.15     220
  355.14  217.01  376.12  214.51  404.11  211.55  432.09  214.49  446.08  215.18
  502.05  215.36  532.99  213.69  551.02  211.18  558.01  211.88  565.01  214.61
  572.01   218.9     579  221.97  599.99  229.03  627.97  239.92  662.95  249.68
  683.94  253.58  697.93  257.23   753.9  265.33  809.86  270.26   833.8   271.6
#Mann= 3 , 0 , 0
       0     .09       0  376.12    .045       0  432.09     .09       0
Bank Sta=376.12,432.09
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7574    ,652.65,845.23,904.54
BEGIN DESCRIPTION:
Based on the old FIRM it appears the main channel as defined by the stream centerline is on the left side of the overbank. The old FIRM also shows the Floodway on the left side. Will assume this is correct.
END DESCRIPTION:
XS GIS Cut Line= 2
1648300.74223539744956.5540257251647533.61633384744944.492297709
#Sta/Elev= 30
       0   258.4    35.3  257.34   84.44  254.87  133.33  251.27  168.25   250.4
  224.12  245.22  252.05   240.3     273  234.51  307.92  217.26  314.91  214.27
   326.2  210.93  335.86  209.02  347.49  208.53  356.81  208.96  375.87  212.13
  398.71  211.64  419.66  212.31  468.11  211.82  475.53  211.27   489.5  208.89
  496.48  208.57  510.45  211.64   531.4  213.21  545.37  216.06  566.32  221.94
  594.25  231.99   631.3  243.06  699.01  255.33  744.82  261.79  767.22  263.91
#Mann= 3 , 0 , 0
       0     .09       0   326.2    .045       0  375.87     .09       0
Bank Sta=326.2,375.87
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6728    ,767.37,1002.72,846.19
XS GIS Cut Line= 3
1648212.45038633744723.5214404761648051.27657934743950.354337275
1647938.31856315743849.279058814
#Sta/Elev= 30
       0   221.1    20.7  217.94   69.51  213.93   83.75  212.99  105.17  212.46
  126.57  211.18  164.88  209.85   197.9  207.85  269.23   207.2  297.76  206.56
  340.56  206.99  376.22  208.03  381.16  207.29  411.89  204.19  425.92  206.52
  440.42  207.74  453.25  209.01  468.95  209.09  504.62  210.82  526.02  211.18
  568.81  215.29  597.34  217.03  665.44  223.56   761.4  234.75  793.22  237.72
  831.89  239.21  840.07  239.92  858.81  242.86  896.29  241.88  941.36  245.01
#Mann= 3 , 0 , 0
       0     .09       0  381.16    .045       0  440.42     .09       0
Bank Sta=381.16,440.42
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5726    ,736.24,774.85,650.37
XS GIS Cut Line= 3
1648898.03900652744646.0047351271648865.87439853 744086.34055537
1648936.63653618743719.664023817
#Sta/Elev= 30
       0  224.35  109.42  213.81  137.39  210.35  186.35  207.97  214.33  205.65
  284.27  202.57  354.22  200.79   382.2  201.45  430.51  200.78  459.13  196.87
  467.62  197.11  487.11  200.19  515.09  202.45  549.25  202.86  571.22  204.07
  599.67  207.67  634.93  207.97  664.74  209.42  677.89   211.3  692.12   214.2
  754.16  221.83  801.85  230.29  820.13  231.89  848.57  233.23  877.02  237.44
  891.24  238.65  897.23  238.04  903.19  238.75  915.11  242.05  933.91  243.18
#Mann= 3 , 0 , 0
       0     .09       0  430.51    .045       0  487.11     .09       0
Bank Sta=430.51,487.11
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4951    ,582.46,567.67,468.95
XS GIS Cut Line= 2
1649751.36605763744411.2030964791649211.00064273  743687.4994158
#Sta/Elev= 30
       0  235.81   17.59  231.77   52.44   228.8   91.42  217.71  138.11  208.47
  149.78  205.36  157.02   204.5  174.45  204.44  231.48  199.33  261.59  198.22
   322.6  197.73  359.86  194.94  462.03  194.79  488.25  191.26  496.89  191.04
  511.59  191.67  523.03  194.16  551.54     200  575.32  203.78  616.63  209.91
  663.32  215.24  697.32  222.56  733.34  226.19  768.36  233.26   791.7  235.82
  819.33  237.23  826.71  238.19   862.9  246.21  885.07   249.3  903.18  250.78
#Mann= 3 , 0 , 0
       0     .09       0  462.03    .045       0  523.03     .09       0
Bank Sta=462.03,523.03
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4383    ,146.5,360.73,345.01
XS GIS Cut Line= 3
1650285.92033093 743888.787363471650112.49450435743784.731867567
1649449.01874217743658.551268518
#Sta/Elev= 30
       0  221.79   57.05  218.52  111.34  214.09  133.43  211.69  190.44  211.76
  198.58  211.29  227.48  207.09  255.91  204.53  277.23  200.23  298.56  199.99
  326.99  195.28  341.21  192.06  362.41   191.3  390.96  188.42  412.29  191.32
  419.39  191.67  447.82  190.75  502.85  190.73  540.23  192.58  575.77  197.47
   604.2  202.97  625.53   205.6  653.96  210.37   689.5  213.98  739.25  223.44
  760.58  226.86   781.9  228.28  810.05  232.44  831.66  233.99  877.62  241.42
#Mann= 3 , 0 , 0
       0     .09       0  362.41    .045       0  412.29     .09       0
#XS Ineff= 2 , 0
                           418.5          191.67
Permanent Ineff=
       F       F
Bank Sta=362.41,412.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4022    ,100.11,138.3,150.89
BEGIN DESCRIPTION:
Left encroachment station place farther out into the left overbank than required to provide a smoother floodway boundary.
END DESCRIPTION:
XS GIS Cut Line= 4
1650313.66846317743840.2281320391650031.84143978743695.218921646
1649868.69515444 743341.26542668 1649674.4634656743154.650666833
#Sta/Elev= 30
       0  220.08   49.94  218.65  152.03  211.96  191.29   211.8  230.56  209.56
  269.82  205.18  301.23  198.38  316.94  198.26  343.73  196.23  395.16  190.54
  443.68  188.22  552.06  186.89  574.39  182.95  583.84  182.39  597.46  183.31
  605.15  188.38  613.44  196.62  620.53  201.88  628.22  206.18  658.97  217.86
  689.73  223.03  714.69  228.83  765.08  238.38  785.24  239.83  835.64  241.12
  838.73  241.81  855.79  250.45  867.78   254.4  936.42  266.89  976.04  271.69
#Mann= 3 , 0 , 0
       0     .09       0  552.06     .04       0  605.15     .09       0
Bank Sta=552.06,605.15
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,3884    ,85.96,69.39,80.97
XS GIS Cut Line= 4
1650275.51478136743756.9837352781650030.13380621743615.883558288
1650039.96482834743258.6897535181649961.31665111743003.083177626
#Sta/Elev= 30
       0  217.71   87.76  214.86  160.26  209.62  219.24     203  232.75  200.72
  248.86  195.85  256.74  194.64  273.03  194.28  311.85  190.83  435.11  186.61
  472.51  186.78  486.49  186.04  500.46  183.29  521.41  181.35   528.4  182.36
  543.89  186.99  570.31  194.86  591.27  198.32  618.67  195.51  647.46  195.56
   691.3  199.13  754.42  201.66  764.36  201.27  771.66  202.42  793.58  209.97
  800.89  210.92   822.8  211.86  852.03  211.27  888.56  213.31  907.82  215.86
#Mann= 3 , 0 , 0
       0     .08       0  472.51     .04       0  543.89     .08       0
#XS Ineff= 2 , 0
          502.66  187.67  538.19          187.57
Permanent Ineff=
       F       F
Bank Sta=472.51,543.89
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 3 ,3843    ,,,
BEGIN DESCRIPTION:
Little Egypt Road
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
25,32,2.6,0, 235, 236, 187.6, , 0.95, 0, 0,0,,
      30    34.9   40.62   42.92   45.91   50.94   54.82   58.96   64.33   66.98
   69.02      75   82.76   83.02   83.22   91.04   97.42   99.06  101.18  107.08
  111.62   115.1  119.61  123.12  125.82  131.13  138.03  139.15  140.02  147.17
  154.22  155.19  156.46  163.21  168.42  171.23  174.88  179.25  182.62  187.27
  193.31  195.29  196.82  203.31  211.02  211.33  211.73  219.35  225.22  227.37
  230.16  235.39  239.42  243.41  248.58  251.43  253.62  259.45     267  267.46
  267.82  275.48  279.42   280.7  284.09  287.68  291.01  294.67  297.93  301.65
  304.85  308.63  311.78  315.61   318.7   322.6  325.62  329.58  332.54  336.56
  339.47  343.55  346.39  350.53  353.31  357.51  360.23   364.5  367.15  371.48
  374.08  378.46     381  385.45  387.92  392.43  394.84  399.41  401.77  406.39
  408.69  413.38  415.61  420.36  422.53  427.34  429.46  434.33  436.38  441.31
   443.3  448.29  450.22  455.28  457.15  462.26  464.07  469.24  470.99  476.23
  477.91  483.21  484.84  490.19  491.76  497.18  512.68  512.68  530.08  530.08
  532.09  533.29  539.07  540.21  546.06  547.14  553.04  554.06  560.02  560.98
  567.01   567.9  573.99  574.83  580.97  581.75  587.96  588.67  594.94  595.59
  601.92  602.52  608.91  609.44  615.89  616.36  622.87  623.28  629.85  630.21
  636.84  637.13  643.82  644.05   650.8  650.97  653.01  657.98  660.17  665.24
  670.32   672.5  677.96  679.76  680.47  687.02  690.62  694.28  700.77  701.54
  703.46   708.8  710.92  716.06  721.07  723.32  728.96  730.58  731.22  737.84
  741.37   745.1  751.52  752.36  754.46  759.62  761.67  766.88  771.83  774.14
  779.96   781.4  781.98  788.66  792.13  795.92  802.28  803.18  805.46  810.44
  812.43   817.7  822.58  824.96  830.96  832.22  832.73  839.49  842.88  846.75
  853.03  854.01  856.46  861.27  863.18  868.53  873.33  875.79  881.96  883.05
  883.48  890.31  893.63  897.57  898.34
  217.61  217.59  217.67  217.72  217.69  217.65  217.55  217.38  217.17  217.07
  216.99  216.75  216.44  216.42  216.41  215.94  215.11   214.9   214.7  214.16
  213.95  213.75  213.44   213.2  213.06  212.79  212.18  212.08  212.03  211.59
  211.01  210.92  210.78  210.06  209.43  209.09  208.75  208.34  207.92  207.28
  206.78  206.61  206.49  205.94  204.99  204.96  204.93   204.3   203.8  203.56
  203.13  202.32   201.7   201.1  200.28  199.84  199.31  197.66  195.24  195.08
  195.01  193.62  193.49  193.38  193.27  193.03  192.85  192.67  192.51  192.39
  192.25  192.06  191.96  191.77   191.6  191.44  191.24  191.08  190.92  190.64
  190.46  190.39  190.23  189.93  189.93  190.04  189.89  189.59  189.43  189.29
  189.24  189.12     189  188.84  188.79  188.72  188.63  188.58   188.5  188.37
  188.28  188.18  188.12  187.98  187.96  187.86  187.89   187.9   187.9  187.88
  187.87  187.95  187.97  187.97  187.94  187.92  187.94  187.93  187.95  188.06
  187.94  187.98  187.81  187.61   187.6   187.6   187.6   189.9   189.9   187.6
   187.6   187.6  187.68  187.92  188.72  188.87  189.16  189.25  189.53  189.68
  190.16   190.2   190.3  190.27  190.22  190.26  190.54  190.52   190.6  190.58
  190.77   190.8  191.25  191.28  191.84  191.87  192.33  192.36  192.91  192.93
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                                                           186.2   186.2
       0     4.9   10.62   12.92   15.91   20.94   24.82   28.96   34.33   36.98
   39.02      45   52.76   53.02   53.22   61.04   67.42   69.06   71.18   77.08
   81.62    85.1   89.61   93.12   95.82  101.13  108.03  109.15  110.02  117.17
  124.22  125.19  126.46  133.21  138.42  141.23  144.88  149.25  152.62  157.27
  163.31  165.29  166.82  173.31  181.02  181.33  181.73  189.35  195.22  197.37
  200.16  205.39  209.42  213.41  218.58  221.43  223.62  229.45     237  237.46
  237.82  245.48  249.42   250.7  254.09  257.68  261.01  264.67  267.93  271.65
  274.85  278.63  281.78  285.61   288.7   292.6  295.62  299.58  302.54  306.56
  309.47  313.55  316.39  320.53  323.31  327.51  330.23   334.5  337.15  341.48
  344.08  348.46     351  355.45  357.92  362.43  364.84  369.41  371.77  376.39
  378.69  383.38  385.61  390.36  392.53  397.34  399.46  404.33  406.38  411.31
   413.3  418.29  420.22  425.28  427.15  432.26  434.07  439.24  440.99  446.23
  447.91  453.21  454.84  460.19  461.76  467.18  468.68  484.16  484.16  501.46
  501.46  502.09  503.29  509.07  510.21  516.06  517.14  523.04  524.06  530.02
  530.98  537.01   537.9  543.99  544.83  550.97  551.75  557.96  558.67  564.94
  565.59  571.92  572.52  578.91  579.44  585.89  586.36  592.87  593.28  599.85
  600.21  606.84  607.13  613.82  614.05   620.8  620.97  623.01  627.98  630.17
  635.24  640.32   642.5  647.96  649.76  650.47  657.02  660.62  664.28  670.77
  671.54  673.46   678.8  680.92  686.06  691.07  693.32  698.96  700.58  701.22
  707.84  711.37   715.1  721.52  722.36  724.46  729.62  731.67  736.88  741.83
  744.14  749.96   751.4  751.98  758.66  762.13  765.92  772.28  773.18  775.46
  780.44  782.43   787.7  792.58  794.96  800.96  802.22  802.73  809.49  812.88
  816.75  823.03  824.01  826.46  831.27  833.18  838.53  843.33  845.79  851.96
  853.05  853.48  860.31  863.63  867.57  868.34
  217.61  217.59  217.67  217.72  217.69  217.65  217.55  217.38  217.17  217.07
  216.99  216.75  216.44  216.42  216.41  215.94  215.11   214.9   214.7  214.16
  213.95  213.75  213.44   213.2  213.06  212.79  212.18  212.08  212.03  211.59
  211.01  210.92  210.78  210.06  209.43  209.09  208.75  208.34  207.92  207.28
  206.78  206.61  206.49  205.94  204.99  204.96  204.93   204.3   203.8  203.56
  203.13  202.32   201.7   201.1  200.28  199.84  199.31  197.66  195.24  195.08
  195.01  193.62  193.49  193.38  193.27  193.03  192.85  192.67  192.51  192.39
  192.25  192.06  191.96  191.77   191.6  191.44  191.24  191.08  190.92  190.64
  190.46  190.39  190.23  189.93  189.93  190.04  189.89  189.59  189.43  189.29
  189.24  189.12     189  188.84  188.79  188.72  188.63  188.58   188.5  188.37
  188.28  188.18  188.12  187.98  187.96  187.86  187.89   187.9   187.9  187.88
  187.87  187.95  187.97  187.97  187.94  187.92  187.94  187.93  187.95  188.06
  187.94  187.98  187.81  187.61   187.6   187.6   187.6   187.6   189.9   189.9
   187.6   187.6   187.6  187.68  187.92  188.72  188.87  189.16  189.25  189.53
  189.68  190.16   190.2   190.3  190.27  190.22  190.26  190.54  190.52   190.6
  190.58  190.77   190.8  191.25  191.28  191.84  191.87  192.33  192.36  192.91
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                                                                   186.2   186.2
BR Coef=-1 , 0 , 0 ,, 0 ,,,0.8,0,,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,3815    ,147.26,147.05,139.66
BEGIN DESCRIPTION:
Added dummy right 'levee' in floodplain. Based on upstream and downstream XS, this area appears to be isolated.
END DESCRIPTION:
XS GIS Cut Line= 4
1650293.33894473743706.8780174111650089.11993907743612.606550947
 1650098.9509612743230.8351907881650015.38727292742971.951607496
#Sta/Elev= 30
       0  217.79   19.21     218   80.35   214.2  118.81  210.93  164.95  205.54
   211.1   201.7  243.45   195.7  278.38  191.37  320.29  189.17  355.22   188.6
  376.17  187.16  432.05   186.6  452.72  187.19  466.98   184.6  493.78  181.58
     500  182.54  514.01  186.28  522.86  188.14  536.83  189.39  568.48  190.55
  592.71  187.57  621.66  194.43  628.69  195.74  643.42  196.21  654.17  198.62
  665.38  202.09  680.05  204.22   709.4  207.12  757.08     208  878.86   218.7
#Mann= 3 , 0 , 0
       0     .08       0  452.72     .04       0  514.01     .08       0
#XS Ineff= 2 , 0
       0     479   185.7     507       0   185.7
Permanent Ineff=
       F       F
#Block Obstruct= 1 ,-1
  568.33  604.06  190.54
Bank Sta=452.72,514.01
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,3668    ,425.33,410.55,407.81
XS GIS Cut Line= 4
1650394.26325357743701.1653206351650220.97811943743527.880186498
1650226.88278736743120.3772681061650173.37231335742884.249688342
#Sta/Elev= 30
       0  209.27   82.31  211.37  147.15  210.56  190.93  204.73  240.31  195.36
  269.64  191.64  290.59  187.53  353.44  184.71  444.23  183.08  465.18  183.62
  486.13   181.2  507.08  180.05  514.06  180.78   523.4  183.75  548.98  197.38
  555.96  199.77  569.93   202.7   583.9  203.95  604.85  211.83  618.81  215.29
  660.92  221.65  703.88   230.8  725.36  233.36  761.16  239.28  775.48  240.17
  812.12  246.54  847.08  250.81  868.56  249.95  876.93   251.7  894.72  257.46
#Mann= 3 , 0 , 0
       0     .08       0  465.18     .04       0   523.4     .08       0
Bank Sta=465.18,523.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3257    ,309,317.84,262.36
XS GIS Cut Line= 4
1650743.64421548743711.3012256471650647.15039141743505.447734252
1650621.41870493743116.2559770641650576.38825376742858.939112797
#Sta/Elev= 30
       0  215.06   21.49  213.99   36.91  212.43   52.33  212.39   67.76  211.37
   90.89  208.12  168.01  201.45  206.57  196.61  257.48  187.82  292.47   184.5
  334.46  183.94  378.64  180.21  404.44  179.73  446.43  180.39  451.38  180.02
  467.43  177.06  481.42  176.25  495.42  176.74  502.42   179.3  509.41  182.86
  516.41  185.54   544.4  193.38   565.4  196.73  586.39  202.54  671.06  220.16
  749.04  238.43   770.3  240.78  805.75  242.71  827.01  246.25  878.62  251.16
#Mann= 3 , 0 , 0
       0     .08       0  451.38    .045       0  502.42     .08       0
#XS Ineff= 2 , 0
           446.7  180.42
Permanent Ineff=
       F       F
Bank Sta=451.38,502.42
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2939    ,295.92,379.56,346.57
XS GIS Cut Line= 3
1651087.80552146743666.2707744391650856.22034359743125.905359492
1650733.99483314742775.311131954
#Sta/Elev= 30
       0  213.29   32.95  212.58   41.42  211.84   57.12  209.96   86.13  204.94
   110.3  203.72   162.1  197.65  260.87  191.54  291.25  188.75  329.24  183.17
  352.03  182.15  374.82  179.56  393.92  179.14  412.81  176.96   447.1  173.26
  481.18  177.18  511.57  176.67  526.76   177.2  564.75  180.12  602.34  188.67
  624.52  190.24   661.5  195.06  700.24   201.5  735.45  208.38  824.19  223.98
  868.56  233.39  883.35  235.06  920.33  241.39  935.12  243.07  959.19  244.57
#Mann= 3 , 0 , 0
       0     .08       0  412.81    .045       0  481.18     .08       0
Bank Sta=412.81,481.18
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2560    ,318.49,357.79,365.13
XS GIS Cut Line= 3
1651232.00907989743563.2614339291651163.46113323742923.480598241
1651083.48852876742649.288811356
#Sta/Elev= 30
       0  209.27   25.18  205.51   44.93  205.08  210.11  192.24  263.96  185.34
  299.07  178.52  341.21  177.72  439.53  178.25  467.62  176.96  474.64  174.49
  481.66  172.26  495.71  171.06  516.78  172.94  530.82   175.3  551.89  178.06
  564.06  178.18  587.65  175.21  594.03  176.58  608.07  182.15   615.1   183.6
   673.3  191.43  715.92  201.26  744.61  206.91  759.56  209.06  774.11  209.02
  795.93  210.83  817.75  214.06  839.57  218.56  868.67  223.12  929.06  235.27
#Mann= 3 , 0 , 0
       0     .08       0  474.64    .045       0  530.82     .08       0
#XS Ineff= 2 , 0
       0  439.65  178.45  560.35       0  178.45
Permanent Ineff=
       F       F
Bank Sta=474.64,530.82
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2202    ,450.75,505.22,451.38
XS GIS Cut Line= 2
1651462.84485109743528.6062520741651540.03991036742508.988177419
#Sta/Elev= 30
       0  199.85   25.37  198.84   46.38  195.96   109.4  190.16  200.44  185.27
  270.47  177.74  479.73  177.78  518.79  179.46  529.57  178.98  557.85  173.18
  570.87  171.83   592.6  169.17   606.6  168.39  613.61  168.91  620.61  171.62
  634.61  178.52  641.62  180.05  690.64  185.54  746.64  188.26  767.67   193.2
  795.68  196.57  816.69  197.84  830.69  200.79  858.71  202.82  883.35  208.41
  896.37  210.35  961.47  214.02  970.75   215.5  991.76  220.71 1022.54     226
#Mann= 3 , 0 , 0
       0      .1       0  570.87    .045       0  620.61      .1       0
#XS Ineff= 2 , 0
          518.06   179.5
Permanent Ineff=
       F       F
Bank Sta=570.87,620.61
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1697    ,569.32,639.49,534.2
XS GIS Cut Line= 2
1651968.03599761743581.9040464911651848.82009825742556.647311911
#Sta/Elev= 30
       0  204.12   39.59  199.07   86.15  194.59  158.92  189.94   191.6   189.8
  198.63  188.67  205.66   186.7  230.51  176.24  238.46  173.54   261.9  169.98
  282.99  169.24  349.83  169.51  365.74  168.36  381.41  165.56  388.44  165.15
  413.47  167.49  451.71  169.15  486.86  169.55  507.95  170.87  571.22  172.72
  592.31  174.31  648.54  175.43  697.75   178.5  718.84  180.47  775.08  182.05
  835.08  188.14  894.59  191.21  923.68     196  971.92  205.91 1032.16  211.55
#Mann= 3 , 0 , 0
       0     .08       0  349.83    .045       0  451.71     .09       0
Bank Sta=349.83,451.71
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1057    ,346.08,429.16,429.92
XS GIS Cut Line= 4
1652389.18556246743364.5667511371652405.26786649743062.219435617
1652302.34112079 742711.625208051652170.46622789742431.793118119
#Sta/Elev= 30
       0  197.86   30.15  195.13   84.83  193.57   123.1  190.31  149.66  189.39
  161.75  187.96  259.65  183.02  316.11   177.1  359.77  176.78  394.86  171.58
  410.72  171.65  448.87  169.71  505.33  168.42  548.03  165.58  563.55   162.6
   578.1  161.73  592.66  162.74  607.21  165.95  658.15  170.07  703.86  176.17
  733.44  177.47   757.9  180.69  785.34   181.7   796.5  182.81  873.69  195.42
  889.13  198.53  904.57  200.12  923.23  203.71  943.16  208.89  977.51  212.84
#Mann= 3 , 0 , 0
       0     .07       0  548.03    .045       0  607.21     .09       0
Bank Sta=548.03,607.21
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,628     ,327.74,353.28,393
XS GIS Cut Line= 2
1652587.95867431743307.7074779571652778.70411329742365.901873007
#Sta/Elev= 30
       0   194.4   35.54  190.22   49.79  187.83   64.77  186.71  128.16  183.93
  165.49  183.44  206.53  181.28  230.66  181.35   256.4  180.13  295.83  176.76
  320.52  172.16   337.3  173.34  363.27  172.51  372.85  171.35   384.7  168.54
  396.55  166.75  427.39  167.78  525.68  161.71  550.59  158.52  562.44  158.41
  569.89  159.12  580.21  161.65  591.26  163.29  612.63  164.06  634.01  165.85
  663.16  166.28  680.93   167.3  733.75  172.71  897.62  183.95  960.93  185.96
#Mann= 3 , 0 , 0
       0     .07       0  525.68    .045       0  580.21     .08       0
Bank Sta=525.68,580.21
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,275     ,260.43,225.12,174.43
XS GIS Cut Line= 3
1652782.88036481743351.7009078711653088.44414116742782.387345731
1653139.90751402742547.585707083
#Sta/Elev= 30
       0  188.61   10.21  187.05   32.58  181.94   58.37   179.7   74.26  179.67
   99.62  174.69  202.77  162.97  247.96  161.59  269.81  162.82  295.51   159.7
  319.29  159.23  342.01  159.66  372.95  158.73  414.39  160.02  439.99  159.84
  454.01  158.44  469.86  155.68  486.41  155.42  517.41  159.77  533.26  162.11
  553.45   163.3  579.23  166.03  596.66   168.7   658.7  173.84  680.15  177.02
  710.79  178.84  737.33  183.63  758.78  186.15  815.97  188.47  886.51   194.1
#Mann= 3 , 0 , 0
       0     .07       0  439.99    .045       0  517.41     .08       0
#XS Ineff= 2 , 0
       0  420.96  160.11               0
Permanent Ineff=
       F       F
Bank Sta=439.99,517.41
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50      ,279.52,293.69,281.68
XS GIS Cut Line= 2
 1653204.2367301743467.4934967761653223.53549485742631.213687912
#Sta/Elev= 30
       0     183   24.29  179.21   82.91  172.63  117.84  167.47  152.76  166.94
  159.75   166.5  166.73  165.69   180.7  163.17  201.65   162.5  222.28  163.16
  243.56  162.21  264.52  160.72  299.44  159.75  320.39  157.76  331.52  157.27
  446.12  156.58  460.09  155.25  474.06     153  488.03   153.2  510.76  156.23
  536.92  159.09  550.89   160.1  571.84   165.6  585.81  166.19  648.68  171.87
  669.63  173.19  711.54  177.02  739.48  178.53  802.59   184.7   836.5  186.67
#Mann= 3 , 0 , 0
       0     .07       0  446.12    .045       0  510.76     .08       0
Bank Sta=446.12,510.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,-244    ,23.9,23.83,23.73
XS GIS Cut Line= 2
1653484.06881993743512.5239480881653496.93466316742521.854020655
#Sta/Elev= 30
       0  177.99   44.13  177.73   79.05   174.8  134.92  168.11   183.8   165.2
   267.6  161.55  288.55  161.68  323.55  159.87  426.96  157.23  442.19   156.5
  463.14  153.55  498.06   150.3  505.04  150.91  512.02  152.65  525.99  157.54
  532.97  158.99  539.96  159.41  574.87  160.02  588.84  161.44  602.81  164.26
  630.74  164.97  644.71  166.25     686  166.28  714.54  169.47  728.51  169.97
  763.43  174.95  819.91  181.13  910.08   195.9  924.04  197.44  990.75  201.36
#Mann= 3 , 0 , 0
       0     .07       0  426.96    .045       0  539.96     .08       0
Bank Sta=426.96,539.96
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
Stream Node=Christina       ,Christina       , 0 , 0 ,Upstream end
Stream Node=Christina       ,Christina       , 0 , 1 ,Downstream end

Chan Stop Cuts=-1
Use User Specified Reach Order=0
